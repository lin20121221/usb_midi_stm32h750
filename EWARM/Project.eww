<?xml version="1.0" encoding="UTF-8"?>
<workspace>
  <project>
    <path>$WS_DIR$\stm32h750_usb_midi.ewp</path>
  </project>
  <batchBuild />
</workspace>
